<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ParamOrganizerTest.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>DEBUG</name>
            <member>
                <project>ParamOrganizerTest</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
