# IAR project eFSSTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Code\Inc; ..\..\Code\Src; ..\TestFunction\Inc; ..\TestFunction\Src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: eFSSTest.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group eFSS/Inc
    ../../Code/Inc/: eFSS.h eFSSType.h Prv_eFSSRaw.h Prv_eFSSUtils.h
  group eFSS/Src
    ../../Code/Src/: eFSS.c Prv_eFSSRaw.c Prv_eFSSUtils.c
  group Test
    ./: main.c
  group Test/Inc
    ../TestFunction/Inc/: Prv_eFSSUtilsTest.h
  group Test/Src
    ../TestFunction/Src/: Prv_eFSSUtilsTest.c
