<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\eFFSTest.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>DEBUG</name>
            <member>
                <project>eFFSTest</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
